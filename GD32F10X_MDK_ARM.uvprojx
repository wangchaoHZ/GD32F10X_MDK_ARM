# Keil uVision project GD32F10X_MDK_ARM.uvprojx, settings and files
target GD32F10X_TARGET (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32F10X_MDK_ARM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;.\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;.\Utilities;.\GD32F10x_Firmware_Library\CMSIS;.\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./Source/: gd32f10x_it.c main.c systick.c
  group CMSIS
    ./GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ./GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ./GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
